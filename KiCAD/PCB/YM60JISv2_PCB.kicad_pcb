# Repository ymkn/YM60JISv2

File README.md:

# YM60JISv2

The successor to the YM60JIS. A 60% PCB supporting both MX and Gateron Low Profile 3.0 compatible switches with universal tray mount case.

## Default Layout

You can also customize the layout using [Vial](https://get.vial.today/).

## Build Guide

See [Build Guide](https://ymkn.github.io/buildguide/ym60jisv2.html).

## License

This project is licensed under the MIT License, see the [LICENSE file](LICENSE) for details.

However, this does not apply to logo data (image files, KiCAD footprints, etc.) included in the resources of this project.

## KiCad design KiCAD/PCB/YM60JISv2_PCB.kicad_pcb

Parts:
BTN_BOOT1: SW_Push; SW_Push_1P1T_XKB_TS-1187A; JLCPCB Part # C318884
C1, C2: 10uF; C_0603_1608Metric; JLCPCB Part # C19702
C3, C4, C5, C6, C8: 100nF; C_0402_1005Metric; JLCPCB Part # C1525
C7: 10nF; C_0402_1005Metric; JLCPCB Part # C15195
C9, C10: 4.7uF; C_0402_1005Metric; JLCPCB Part # C23733
C11: 1uF; C_0402_1005Metric; JLCPCB Part # C52923
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52, D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64, D65, D66, D67, D68: 1N4148W; D_SOD-123; LCSC Parts # C81598
FB1: FerriteBead; L_0603_1608Metric; JLCPCB Part # C14709
J1: TYPE-C 16PIN 2MD(073); USB_C_Receptacle_HRO_TYPE-C-31-M-12; JLCPCB Part # C2765186
R1, R2: 5.1K; R_0402_1005Metric; JLCPCB Part # C25905
R3: 10K; R_0402_1005Metric; JLCPCB Part # C25744
SW1, SW4, SW6, SW7, SW8, SW9, SW11, SW12, SW13, SW14, SW16, SW17, SW18, SW19, SW21, SW22, SW23, SW24, SW25, SW26, SW27, SW28, SW29, SW30, SW31, SW32, SW33, SW34, SW35, SW36, SW37, SW39, SW40, SW41, SW42, SW43, SW44, SW45, SW46, SW47, SW48, SW49, SW50, SW51, SW52, SW53, SW54, SW55, SW56, SW57, SW58, SW59, SW60, SW61, SW62, SW63, SW64, SW65, SW66, SW67, SW68: SW_Push; SW_MX_GLP3_1u; LCSC Parts # C18212911
SW2: SW_Push; SW_MX_GLP3_1.5u; LCSC Parts # C18212911
SW3: SW_Push; SW_MX_GLP3_1.75u; LCSC Parts # C18212911
SW5, SW10, SW15, SW20, SW38: SW_Push; SW_MX_GLP3_1.25u; LCSC Parts # C18212911
U1: SRV05-4-P-T7; SOT-23-6; JLCPCB Part # C85364
U2: XC6206P332MR; SOT-23-3; JLCPCB Part # C5446
U3: STM32F072CBU6; UFQFPN48-7x7mm; JLCPCB Part # C92504

Connections:
+3V3: BTN_BOOT1.1, C2.1, C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, U2.2 (VO), U3.1 (VBAT), U3.9 (VDDA), U3.24 (VDD), U3.36 (VDDIO2), U3.48 (VDD)
+5V: C1.1, J1.A4 (VBUS), J1.A9 (VBUS), J1.B4 (VBUS), J1.B9 (VBUS), U1.5 (VBUS), U2.3 (VI)
BOOT: BTN_BOOT1.2, R3.2, U3.44 (BOOT0)
COL0: SW1.2, SW2.2, SW3.2, SW4.2, SW5.2, U3.22 (PB11)
COL1: SW6.2, SW7.2, SW8.2, SW9.2, SW10.2, U3.38 (PA15)
COL2: SW11.2, SW12.2, SW13.2, SW14.2, SW15.2, U3.40 (PB4)
COL3: SW16.2, SW17.2, SW18.2, SW19.2, SW20.2, U3.41 (PB5)
COL4: SW21.2, SW22.2, SW23.2, SW24.2, U3.42 (PB6)
COL5: SW25.2, SW26.2, SW27.2, SW28.2, SW29.2, U3.10 (PA0)
COL6: SW30.2, SW31.2, SW32.2, SW33.2, U3.11 (PA1)
COL7: SW34.2, SW35.2, SW36.2, SW37.2, SW38.2, U3.12 (PA2)
COL8: SW39.2, SW40.2, SW41.2, SW42.2, SW43.2, U3.13 (PA3)
COL9: SW44.2, SW45.2, SW46.2, SW47.2, SW48.2, U3.14 (PA4)
COL10: SW49.2, SW50.2, SW51.2, SW52.2, SW53.2, U3.16 (PA6)
COL11: SW54.2, SW55.2, SW56.2, SW57.2, SW58.2, U3.17 (PA7)
COL12: SW59.2, SW60.2, SW61.2, SW62.2, SW63.2, U3.18 (PB0)
COL13: SW64.2, SW65.2, SW66.2, SW67.2, SW68.2, U3.19 (PB1)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, FB1.2, J1.A1 (GND), J1.A12 (GND), J1.B1 (GND), J1.B12 (GND), R1.1, R2.2, R3.1, U1.2 (GND), U2.1 (GND), U3.8 (VSSA), U3.23 (VSS), U3.35 (VSS), U3.47 (VSS), U3.49 (VSS)
unnamed: D1.2 (A), SW1.1
unnamed: D2.2 (A), SW2.1
unnamed: D3.2 (A), SW3.1
unnamed: D4.2 (A), SW4.1
unnamed: D5.2 (A), SW5.1
unnamed: D6.2 (A), SW6.1
unnamed: D7.2 (A), SW7.1
unnamed: D8.2 (A), SW8.1
unnamed: D9.2 (A), SW9.1
unnamed: D10.2 (A), SW10.1
unnamed: D11.2 (A), SW11.1
unnamed: D12.2 (A), SW12.1
unnamed: D13.2 (A), SW13.1
unnamed: D14.2 (A), SW14.1
unnamed: D15.2 (A), SW15.1
unnamed: D16.2 (A), SW16.1
unnamed: D17.2 (A), SW17.1
unnamed: D18.2 (A), SW18.1
unnamed: D19.2 (A), SW19.1
unnamed: D20.2 (A), SW20.1
unnamed: D21.2 (A), SW21.1
unnamed: D22.2 (A), SW22.1
unnamed: D23.2 (A), SW23.1
unnamed: D24.2 (A), SW24.1
unnamed: D25.2 (A), SW25.1
unnamed: D26.2 (A), SW26.1
unnamed: D27.2 (A), SW27.1
unnamed: D28.2 (A), SW28.1
unnamed: D29.2 (A), SW29.1
unnamed: D30.2 (A), SW30.1
unnamed: D31.2 (A), SW31.1
unnamed: D32.2 (A), SW32.1
unnamed: D33.2 (A), SW33.1
unnamed: D34.2 (A), SW34.1
unnamed: D35.2 (A), SW35.1
unnamed: D36.2 (A), SW36.1
unnamed: D37.2 (A), SW37.1
unnamed: D38.2 (A), SW38.1
unnamed: D39.2 (A), SW39.1
unnamed: D40.2 (A), SW40.1
unnamed: D41.2 (A), SW41.1
unnamed: D42.2 (A), SW42.1
unnamed: D43.2 (A), SW43.1
unnamed: D44.2 (A), SW44.1
unnamed: D45.2 (A), SW45.1
unnamed: D46.2 (A), SW46.1
unnamed: D47.2 (A), SW47.1
unnamed: D48.2 (A), SW48.1
unnamed: D49.2 (A), SW49.1
unnamed: D50.2 (A), SW50.1
unnamed: D51.2 (A), SW51.1
unnamed: D52.2 (A), SW52.1
unnamed: D53.2 (A), SW53.1
unnamed: D54.2 (A), SW54.1
unnamed: D55.2 (A), SW55.1
unnamed: D56.2 (A), SW56.1
unnamed: D57.2 (A), SW57.1
unnamed: D58.2 (A), SW58.1
unnamed: D59.2 (A), SW59.1
unnamed: D60.2 (A), SW60.1
unnamed: D61.2 (A), SW61.1
unnamed: D62.2 (A), SW62.1
unnamed: D63.2 (A), SW63.1
unnamed: D64.2 (A), SW64.1
unnamed: D65.2 (A), SW65.1
unnamed: D66.2 (A), SW66.1
unnamed: D67.2 (A), SW67.1
unnamed: D68.2 (A), SW68.1
unnamed: J1.A5 (CC1), R2.1
unnamed: J1.B5 (CC2), R1.2
unnamed: FB1.1, J1.S1 (SHIELD)
unnamed: C3.1, U3.7 (NRST)
ROW0: D1.1 (K), D6.1 (K), D11.1 (K), D16.1 (K), D21.1 (K), D25.1 (K), D30.1 (K), D34.1 (K), D39.1 (K), D44.1 (K), D49.1 (K), D54.1 (K), D59.1 (K), D64.1 (K), U3.28 (PB15)
ROW0_5: D2.1 (K), U3.29 (PA8)
ROW1: D7.1 (K), D12.1 (K), D17.1 (K), D22.1 (K), D26.1 (K), D31.1 (K), D35.1 (K), D40.1 (K), D45.1 (K), D50.1 (K), D55.1 (K), D60.1 (K), D65.1 (K), U3.39 (PB3)
ROW2: D3.1 (K), D8.1 (K), D13.1 (K), D18.1 (K), D23.1 (K), D27.1 (K), D32.1 (K), D36.1 (K), D41.1 (K), D46.1 (K), D51.1 (K), D56.1 (K), D61.1 (K), D66.1 (K), U3.15 (PA5)
ROW3: D4.1 (K), D9.1 (K), D14.1 (K), D19.1 (K), D24.1 (K), D28.1 (K), D33.1 (K), D37.1 (K), D42.1 (K), D47.1 (K), D52.1 (K), D57.1 (K), D62.1 (K), D67.1 (K), U3.20 (PB2)
ROW4: D5.1 (K), D10.1 (K), D15.1 (K), D20.1 (K), D29.1 (K), D38.1 (K), D43.1 (K), D48.1 (K), D53.1 (K), D58.1 (K), D63.1 (K), D68.1 (K), U3.21 (PB10)
USB_D+: J1.A6 (D+), J1.B6 (D+), U1.1 (I/O1), U1.6 (I/O1), U3.33 (PA12)
USB_D-: J1.A7 (D-), J1.B7 (D-), U1.3 (I/O2), U1.4 (I/O2), U3.32 (PA11)

Notes on the sheet:
※MCU内蔵クロック使用
Crystal
MCU
Key Matrix
※for VDDIO2
※for VDDA
※MCU近傍
※USBコネクタ近傍
BOOT/RESET
※3.3V電源ピン近傍
※差動信号、配線長さ合わせる
USB / Power
※リセットボタン実装無し

Board: 2 copper layers, 285.0 x 94.6 mm, 157 parts (156 on the bottom side), 98 nets.

Other parts of the board:
logo-icononly: logo-icononly
